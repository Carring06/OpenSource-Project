# Keil uVision project .Clion.uvprojx, settings and files
target .Clion (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: _Clion +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\User\Algorithm\Inc;..\User\CallBack\Inc;..\User\Comm_Prot\Inc;..\User\Device\Inc;..\User\System\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Device
    ../User/Device/Src/: BLE_UART.c Encoder.c Motor.c MPU6050.c MyKey.c NRF24L01.c OLED.c OLED_Data.c
    ../User/Device/Inc/: BLE_UART.h Encoder.h Motor.h MPU6050.h MyKey.h NRF24L01.h OLED.h OLED_Data.h
  group Algorithm
    ../User/Algorithm/Src/: CompFilter.c PID.c
    ../User/Algorithm/Inc/: CompFilter.h PID.h
  group CallBack
    ../User/CallBack/Src/: key_callback.c tim_callback.c uart_callback.c
    ../User/CallBack/Inc/: key_callback.h tim_callback.h uart_callback.h
  group Comm_Prot
    ../User/Comm_Prot/Src/: H_I2C.c
    ../User/Comm_Prot/Inc/: H_I2C.h
  group System
    ../User/System/Src/: MyFLASH.c Store.c
    ../User/System/Inc/: MyFLASH.h Store.h
software components: CMSIS:CORE 4.3.0
